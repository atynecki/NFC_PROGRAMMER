# Keil uVision project Project.uvprojx, settings and files
target NFC_PROGRAMMER (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: obj
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0538_DISCO,USE_HAL_DRIVER
  c misc: --C99
  c include: .;.\inc;.\libraries\STM32L0xx_HAL_Driver\Inc;.\libraries\USB\Core\Inc;.\libraries\USB\Class\CDC\Inc;.\libraries\CMSIS\Include;.\libraries\CMSIS\Device\ST\STM32L0xx\Include;.\libraries\BSP\Components\Common;.\libraries\BSP\STM32L0538-Discovery;.\libraries\BSP\Components\gde021a1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group lib
    ./libraries/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group src
    ./src/: main.c app_manager.c stm32l0xx_hal_msp.c stm32l0xx_it.c usbd_conf.c usbd_cdc_interface.c usbd_desc.c system_stm32l0xx.c
  group MDK-ARM
    ./: startup_stm32l053xx.s
  group inc
    ./inc/: app_manager.h stm32l0xx_hal_conf.h stm32l0xx_it.h
  group USB
    ./libraries/USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./libraries/USB/Class/CDC/Src/: usbd_cdc.c
  group drivers
    ./libraries/BSP/Components/gde021a1/: gde021a1.c
    ./libraries/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery_epd.c
software components: CMSIS:CORE 4.1.0
